// Free servo tester - ESP32 Dev Module (classic ESP32-WROOM-32) + PCA9685 16-channel servo driver.
// Same serial protocol and web UI as OTTO/ServoTest (the 1.47" C6 board), but 16 channels over I2C.
// Every channel starts FREE (no signal, servo limp). Control from the web UI (servotest_server.py).
//   Wiring:  ESP32 3V3 -> PCA9685 VCC,  GND -> GND,  GPIO21 -> SDA,  GPIO22 -> SCL
//            separate 5-6 V supply -> PCA9685 V+ (green terminal), its GND joined to ESP32 GND. OE not connected.
//   Commands (one per line):
//     !u,ch,us            hold channel at a pulse width (500..2500 us, 1500 = 90deg)
//     !f,ch               free channel (ch = -1: all)
//     !v,speed            ramp speed in deg/s for all channels (0 = instant)
//     !s,ch,min,max,ms    sweep min..max degrees, full cycle every ms
//     !x,ch               stop sweep (hold current position)
// Telemetry 10 Hz:  S,speed, then per channel: target_us,current_us,measured_us   (0 = free; measured = current if chip answers)
// Arduino IDE: board "ESP32 Dev Module", 115200 baud. (PCA9685 pulse is generated by the chip, so it cannot be read back.)
#include <Wire.h>

#define PIN_SDA 21
#define PIN_SCL 22          // NOTE: GPIO22 is also the MAX98357A DIN in the WAV player wiring - unplug the amp or move I2C to e.g. SDA 18 / SCL 19
#define PCA_ADDR 0x40
#define N 16

struct Ch { float tgt, cur; bool sweep; float mn, mx, per; uint32_t t0; };
Ch ch[N];
float speedDegS = 0;
bool chipOk = false;
const float US_PER_DEG = 2000.0f / 180.0f;

bool w8(uint8_t r, uint8_t v) { Wire.beginTransmission(PCA_ADDR); Wire.write(r); Wire.write(v); return Wire.endTransmission() == 0; }

bool chipInit() {
  if (!w8(0x00, 0x10)) return false;       // sleep to set prescaler
  w8(0xFE, 121);                           // 50 Hz
  w8(0x00, 0x20); delay(5); w8(0x00, 0xA0);
  return true;
}

void out(int i, float us) {
  Wire.beginTransmission(PCA_ADDR);
  Wire.write(0x06 + 4 * i);
  uint16_t off = us <= 0 ? 0x1000 : (uint16_t)(us * 4096.0f / 20000.0f);   // 0x1000 in OFF_H bit4 = full off (limp)
  Wire.write(0); Wire.write(0); Wire.write(off & 255); Wire.write(off >> 8);
  chipOk = Wire.endTransmission() == 0;
}

void cmd(const String &l) {
  char k = l.length() > 1 ? l[1] : 0;
  int a = -9, b = 0, c = 0, d = 0;
  int n = sscanf(l.c_str() + 2, ",%d,%d,%d,%d", &a, &b, &c, &d);
  if (k == 'v') { speedDegS = max(0, a); return; }
  if (k == 'f' && a == -1) { for (int i = 0; i < N; i++) { ch[i].tgt = ch[i].cur = 0; ch[i].sweep = false; out(i, 0); } return; }
  if (n < 1 || a < 0 || a >= N) return;
  Ch &h = ch[a];
  if (k == 'u' && n >= 2) { h.sweep = false; h.tgt = constrain(b, 500, 2500); if (h.cur <= 0 || speedDegS == 0) h.cur = h.tgt; }
  else if (k == 'f') { h.tgt = h.cur = 0; h.sweep = false; out(a, 0); }
  else if (k == 's' && n >= 4) {
    h.mn = constrain(b, 0, 180); h.mx = constrain(c, 0, 180); h.per = max(300, d);
    h.t0 = millis(); h.sweep = true; if (h.cur <= 0) h.cur = 500 + (h.mn + h.mx) / 2 * US_PER_DEG;
  }
  else if (k == 'x') { h.sweep = false; h.tgt = h.cur; }
}

void readSerial() {
  static String line; static bool in = false;
  while (Serial.available()) {
    char c = Serial.read();
    if (in) { if (c == '\n') { cmd(line); in = false; } else if (c != '\r' && line.length() < 48) line += c; continue; }
    if (c == '!') { in = true; line = "!"; }
  }
}

void setup() {
  Serial.begin(115200);
  Wire.begin(PIN_SDA, PIN_SCL); Wire.setClock(400000);
  chipOk = chipInit();
  for (int i = 0; i < N; i++) out(i, 0);
  Serial.println(chipOk ? "ServoTestPCA ready - PCA9685 found, all channels FREE" : "PCA9685 NOT FOUND - check SDA/SCL, VCC, GND");
}

void loop() {
  readSerial();
  static uint32_t tStep = 0, tTel = 0, tRetry = 0;
  uint32_t now = millis();
  if (now - tStep >= 10) {
    float dt = (now - tStep) / 1000.0f; tStep = now;
    for (int i = 0; i < N; i++) {
      Ch &h = ch[i];
      if (h.sweep) {
        float mid = (h.mn + h.mx) / 2, amp = (h.mx - h.mn) / 2;
        h.tgt = h.cur = 500 + (mid + amp * sin(2 * PI * (now - h.t0) / h.per)) * US_PER_DEG;
      } else if (h.tgt > 0) {
        if (speedDegS <= 0) h.cur = h.tgt;
        else { float step = speedDegS * US_PER_DEG * dt; h.cur += constrain(h.tgt - h.cur, -step, step); }
      } else continue;                                   // free: send nothing
      out(i, h.cur);
    }
  }
  if (!chipOk && now - tRetry > 1000) { tRetry = now; chipOk = chipInit(); }
  if (now - tTel > 100) {
    tTel = now;
    Serial.printf("S,%.0f", speedDegS);
    for (int i = 0; i < N; i++) Serial.printf(",%.0f,%.0f,%d", ch[i].tgt, ch[i].tgt > 0 ? ch[i].cur : 0, (chipOk && ch[i].tgt > 0) ? (int)ch[i].cur : 0);
    Serial.println();
  }
}
